# IAR project led_demo_MAPS-KS22F25612.ewp, settings and files
configuration Debug_0000 (ARM, debug)
  General.OGChipSelectEditMenu: MKS22FN256xxx12 Freescale MKS22FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_MKS22FN256VLL12; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\src\include; ..\..\..\..\src\include\device; ..\..\..\..\targets\MKS22F25612\src\startup; ..\..\..\..\src; ..\..\..\..\src\drivers; ..\..\..\..\src\startup
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: BL_HAS_FLASH_CONFIG
  AARM.AUserIncludes: ..\..\..\src\include
  OBJCOPY.OOCOutputFile: led_demo_MAPS-KS22F25612_0000.bin
  ILINK.IlinkOutputFile: led_demo_MAPS-KS22F120M256R_0000.out
  ILINK.IlinkIcfFile: ..\..\..\..\targets\common\linker\iar\MKS22F25612\KS22FN256xxx12_application_0x0000.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug_a000 (ARM, debug)
  as the first configuration, except:
  AARM.ADefines: BL_HAS_BOOTLOADER_CONFIG
  OBJCOPY.OOCOutputFile: led_demo_MAPS-KS22F25612_a000.bin
  ILINK.IlinkOutputFile: led_demo_MAPS-KS22F25612_a000.out
  ILINK.IlinkIcfFile: ..\..\..\..\targets\common\linker\iar\MKS22F25612\KS22FN256xxx12_application_0xA000.icf
  group ks22f256
    ../src/: main.c system_MKS22F25612.c
  group src/startup
    ../../../../src/startup/: crt0.s startup.c
    ../src/: startup_MKS22F25612.s
