# IAR project flashloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKS22FN256xxx12 Freescale MKS22FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CPU_MKS22FN256VLL12; CPU_IS_ARM_CORTEX_M4=1; IAR; BL_TARGET_RAM
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../src; ../../../../src/include; ../../../../src/include/device; ../../../../src; ../../../../src/autobaud; ../../../../src/drivers; ../../../../src/startup; ../../../../src/drivers/uart; ../../../../src/usb_stack/hid_device; ../../../../src/usb_stack/adapter/sources; ../../../../src/usb_stack/adapter/sources/bm; ../../../../src/usb_stack/os/bm; ../../../../src/usb_stack/platform/arch/cortex_m; ../../../../src/usb_stack/platform/soc/mks22f25612; ../../../../src/usb_stack/platform/bsp/mks22f25612; ../../../../src/usb_stack/usb_core/device/include; ../../../../src/usb_stack/usb_core/device/include/mks22f25612; ../../../../src/usb_stack/usb_core/device/sources; ../../../../src/usb_stack/usb_core/device/sources/bsp/mks22f25612; ../../../../src/usb_stack/usb_core/device/sources/classes/common; ../../../../src/usb_stack/usb_core/device/sources/classes/hid; ../../../../src/usb_stack/usb_core/device/sources/classes/include; ../../../../src/usb_stack/usb_core/device/sources/controller; ../../../../src/usb_stack/usb_core/device/sources/controller/khci; ../../../../src/usb_stack/usb_core/device/sources/controller/ehci; ../../../../src/usb_stack/usb_core/hal; ../../../../src/usb_stack/usb_core/include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG
  AARM.AUserIncludes: ../../../../src/include
  OBJCOPY.OOCOutputFile: generic.srec
  postbuild: cmd /c ..\..\..\..\bin\create_flashloader_image.bat $PROJ_DIR$ Debug
  ILINK.IlinkOutputFile: flashloader.elf
  ILINK.IlinkIcfFile: ../../../common/linker/iar/MKS22F25612/KS22FN256xxx12_ram_flashloader.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_uidiv=__iar_small___aeabi_uidiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod; --redirect __aeabi_uidivmod=__iar_small___aeabi_uidivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  postbuild: cmd /c ..\..\..\..\bin\create_flashloader_image.bat $PROJ_DIR$ Release
  group link
    ../../../common/linker/iar/MKS22F25612/: KS22FN256xxx12_ram_flashloader.icf
  group MKS22F25612
    ../../../common/src/: bl_dspi_irq_config_common.c bl_lpi2c_irq_config_common.c
    ../../src/: bootloader_config.h clock_config_KS22F25612.c hardware_init_KS22F25612.c memory_map_KS22F25612.c peripherals_KS22F25612.c
  group src/autobaud
    ../../../../src/autobaud/: autobaud.h
  group src/autobaud/src
    ../../../../src/autobaud/src/: autobaud_irq.c
  group src/bootloader
    ../../../../src/bootloader/: bl_peripheral_interface.h bl_user_entry.h bl_version.h bootloader.h command.h context.h peripheral.h shutdown_cleanup.h
  group src/bootloader/src
    ../../../../src/bootloader/src/: app_crc_check.c bl_user_entry.c bootloader.c bootloader_context.c bootloader_exception_handler.c bootloader_tree_root.c command.c dspi_peripheral_interface.c flexcan_peripheral_interface.c lpi2c_peripheral_interface.c scuart_peripheral_interface.c shutdown_cleanup.c usb_hs_hid_peripheral_interface.c
  group src/crc
    ../../../../src/crc/: crc16.h crc32.h
  group src/crc/src
    ../../../../src/crc/src/: crc16.c crc32.c
  group src/drivers/crc/hal
    ../../../../src/drivers/crc/hal/: fsl_crc_hal.c
  group src/drivers/crc/src
    ../../../../src/drivers/crc/src/: fsl_crc_common.c fsl_crc_driver.c
  group src/drivers/dspi
    ../../../../src/drivers/dspi/: fsl_dspi_slave_driver.h fsl_dspi_types.h
  group src/drivers/dspi/hal
    ../../../../src/drivers/dspi/hal/: fsl_dspi_features.h fsl_dspi_hal.c fsl_dspi_hal.h
  group src/drivers/dspi/src
    ../../../../src/drivers/dspi/src/: fsl_dspi_shared_irqs.c fsl_dspi_slave_driver.c
  group src/drivers/flash
    ../../../../src/drivers/flash/: flash.h
    ../../../../src/drivers/flash/src/: flash_cache_clear.c flash_command_sequence.c flash_densities.h flash_densities_k_series.c flash_erase.c flash_erase_all.c flash_erase_all_unsecure.c flash_get_property.c flash_get_security_state.c flash_init.c flash_is_execute_only.c flash_is_protected.c flash_program.c flash_program_once.c flash_read_once.c flash_read_resource.c flash_security_bypass.c flash_verify_erase.c flash_verify_erase_all.c flash_verify_program.c fsl_flash_features.h SSD_FTFx_Common.h
  group src/drivers/flexcan
    ../../../../src/drivers/flexcan/: fsl_flexcan_driver.h
  group src/drivers/flexcan/hal
    ../../../../src/drivers/flexcan/hal/: fsl_flexcan_hal.c fsl_flexcan_hal.h
  group src/drivers/flexcan/src
    ../../../../src/drivers/flexcan/src/: fsl_flexcan_common.c fsl_flexcan_driver.c fsl_flexcan_irq.c
  group src/drivers/lpi2c
    ../../../../src/drivers/lpi2c/slave/: fsl_lpi2c_slave_driver.h
  group src/drivers/lpi2c/hal
    ../../../../src/drivers/lpi2c/hal/: fsl_lpi2c_hal.c fsl_lpi2c_hal.h
  group src/drivers/lpi2c/src
    ../../../../src/drivers/lpi2c/slave/src/: fsl_lpi2c_slave_driver.c
  group src/drivers/microseconds
    ../../../../src/drivers/microseconds/: microseconds.h
  group src/drivers/microseconds/src
    ../../../../src/drivers/microseconds/src/: microseconds_sysclk.c
  group src/drivers/smc
    ../../../../src/drivers/smc/: smc.c smc.h
  group src/drivers/uart
    ../../../../src/drivers/uart/: scuart.c scuart.h
  group src/include
    ../../../../src/include/: bootloader_common.h fsl_platform_common.h fsl_platform_status.h fsl_platform_types.h
  group src/memory
    ../../../../src/memory/: memory.h
  group src/memory/src
    ../../../../src/memory/src/: device_memory.c device_memory.h flash_memory.c flash_memory.h memory.c normal_memory.c normal_memory.h pattern_fill.h pattern_fill.s sram_init_cm4.c
  group src/packet
    ../../../../src/packet/: command_packet.h serial_packet.h
  group src/packet/src
    ../../../../src/packet/src/: serial_packet.c
  group src/property
    ../../../../src/property/: property.h
  group src/property/src
    ../../../../src/property/src/: property.c
  group src/sbloader
    ../../../../src/sbloader/: sbloader.h
  group src/sbloader/src
    ../../../../src/sbloader/src/: sbloader.c
  group src/startup
    ../../../../src/startup/: crt0.s startup.c
    ../../src/startup/iar/: startup_MKS22F25612.s
    ../../src/startup/: system_MKS22F25612.c
  group src/usb_stack/adapter/sources
    ../../../../src/usb_stack/adapter/sources/: adapter.h adapter_types.h
  group src/usb_stack/adapter/sources/bm
    ../../../../src/usb_stack/adapter/sources/bm/: adapter_bm.c adapter_bm.h adapter_cfg.h
  group src/usb_stack/hid_device
    ../../../../src/usb_stack/hid_device/: bootloader_hid_report_ids.h USB_Config.h usb_descriptor.c usb_descriptor.h
    ../../../../src/usb_stack/hid_device/hid_device/: user_config.h
  group src/usb_stack/os/bm
    ../../../../src/usb_stack/os/bm/: bmevent.c bmevent.h bmisr.c bmmsgq.c bmmsgq.h bmsem.c bmsem.h mem_util.c mem_util.h poll.c poll.h
  group src/usb_stack/platform/arch/cortex_m
    ../../../../src/usb_stack/platform/arch/cortex_m/: nvic.c nvic.h
  group src/usb_stack/platform/bsp/mks22f25612
    ../../../../src/usb_stack/platform/bsp/mks22f25612/: bsp.h derivative.h
  group src/usb_stack/platform/soc/mks22f25612
    ../../../../src/usb_stack/platform/soc/MKS22F25612/: soc.h soc_config.h soc_isr.c soc_isr.h soc_pit.c soc_pit.h soc_usb.c
  group src/usb_stack/usb_core/device/include
    ../../../../src/usb_stack/usb_core/device/include/: usb_device_stack_interface.h
  group src/usb_stack/usb_core/device/include/mks22f25612
    ../../../../src/usb_stack/usb_core/device/include/mks22f25612/: usb_device_config.h
  group src/usb_stack/usb_core/device/sources/bsp/mks22f25612
    ../../../../src/usb_stack/usb_core/device/sources/bsp/mks22f25612/: usb_dev_bsp.c
  group src/usb_stack/usb_core/device/sources/classes/common
    ../../../../src/usb_stack/usb_core/device/sources/classes/common/: usb_class.c usb_class_internal.h
  group src/usb_stack/usb_core/device/sources/classes/hid
    ../../../../src/usb_stack/usb_core/device/sources/classes/hid/: usb_hid.c usb_hid.h usb_hid_config.h
  group src/usb_stack/usb_core/device/sources/classes/include
    ../../../../src/usb_stack/usb_core/device/sources/classes/include/: usb_class.h usb_class_hid.h
  group src/usb_stack/usb_core/device/sources/controller
    ../../../../src/usb_stack/usb_core/device/sources/controller/: ehci_interface.c khci_interface.c usb_dev.c usb_dev.h usb_framework.c usb_framework.h
  group src/usb_stack/usb_core/device/sources/controller/ehci
    ../../../../src/usb_stack/usb_core/device/sources/controller/ehci/: ehci_dev_main.c ehci_dev_main.h ehci_usbprv.h
  group src/usb_stack/usb_core/device/sources/controller/khci
    ../../../../src/usb_stack/usb_core/device/sources/controller/khci/: khci_dev.c khci_dev.h khci_dev_misc.h
  group src/usb_stack/usb_core/hal
    ../../../../src/usb_stack/usb_core/hal/: fsl_usb_ehci_hal.h fsl_usb_khci_hal.c fsl_usb_khci_hal.h
  group src/usb_stack/usb_core/include
    ../../../../src/usb_stack/usb_core/include/: compiler.h types.h usb.h usb_desc.h usb_ehci.h usb_error.h usb_misc.h usb_opt.h usb_types.h
  group src/utilities
    ../../../../src/utilities/: fsl_rtos_abstraction.h
  group src/utilities/src
    ../../../../src/utilities/src/: fsl_assert.c fsl_rtos_abstraction.c
